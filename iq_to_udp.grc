options:
  parameters:
    author: rtl-ml-udp
    comment: SDR → UDP untuk rtl-ml classify_live_udp.py
    copyright: MIT
    description: Stream IQ complex64 dari SDR ke UDP port 5000
    generate_options: no_gui
    id: iq_to_udp
    output_language: python
    title: IQ to UDP (rtl-ml)
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 99.1e6
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain (dB)
    start: '0'
    step: '1'
    stop: '60'
    value: '40'
  states: {state: disabled}
- name: rf_gain_nogui
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: network_udp_sink_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    comment: Kirim IQ ke classify_live_udp.py
    header: '0'
    payloadsize: '1472'
    port: '5000'
    send_eof: 'False'
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: bladerf=0
    bb_gain0: rf_gain_nogui-10
    bw0: samp_rate
    comment: 'Ganti args: bladerf=0 menjadi rtl=0, hackrf=0, dll sesuai SDR Anda'
    freq0: center_freq
    gain0: rf_gain_nogui
    gain_mode0: 'False'
    if_gain0: rf_gain_nogui
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [osmosdr_source_0, '0', network_udp_sink_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
