options:
  parameters:
    author: rtl-ml-udp
    comment: SDR → UDP untuk rtl-ml + Fosphor Spectrum & Waterfall + WBFM Audio
    copyright: MIT
    description: Stream IQ complex64 dari SDR ke UDP port 5000 dengan visualisasi fosphor dan output audio WBFM FM Broadcast
    generate_options: qt_gui
    id: iq_to_udp
    output_language: python
    title: IQ to UDP (rtl-ml) + Fosphor + WBFM Audio
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    comment: samp_rate / audio_decimation = 1024000 / 32 = 32000 Hz
    value: '32000'
  states: {}
- name: audio_volume
  id: variable_qtgui_range
  parameters:
    comment: Slider volume output audio WBFM
    gui_hint: 3,0,1,4
    label: Volume Audio
    min_len: '400'
    start: '0'
    step: '0.05'
    stop: '1.0'
    value: '0.5'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    comment: Slider geser frekuensi tengah
    gui_hint: 0,0,1,4
    label: Frekuensi Tengah (MHz)
    min_len: '400'
    start: 70e6
    step: 10e3
    stop: 1700e6
    value: 99.1e6
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    comment: Slider gain RF
    gui_hint: 1,0,1,4
    label: RF Gain (dB)
    min_len: '400'
    start: '0'
    step: '1'
    stop: '60'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1024000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '32'
    comment: |-
      WBFM demodulator
      Input: complex @ 1024000 sps
      Output: float @ 32000 sps (audio_decimation=32)
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: |-
      Output audio ke speaker/headphone
      Rate: 32000 Hz (32 kSps)
    samp_rate: audio_rate
  states: {}
- name: blocks_multiply_const_vff_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Kontrol volume audio (0.0 - 1.0)
    const: audio_volume
    type: float
  states: {}
- name: fosphor_glfw_sink_c_0
  id: fosphor_glfw_sink_c
  parameters:
    comment: 'Fosphor: spectrum histogram + waterfall GPU-accelerated'
    freq_center: center_freq
    freq_span: samp_rate
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    comment: Kirim IQ ke classify_live_udp.py
    header: '0'
    payloadsize: '1472'
    port: '5000'
    send_eof: 'False'
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    ant0: RX1
    args: bladerf=0
    bb_gain0: rf_gain-10
    bw0: samp_rate
    comment: BladeRF 2.0 — ant RX1 sudah diperbaiki
    dc_offset_mode0: '2'
    freq0: center_freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: rf_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vff_0, '0']
- [blocks_multiply_const_vff_0, '0', audio_sink_0, '0']
- [osmosdr_source_0, '0', analog_wfm_rcv_0, '0']
- [osmosdr_source_0, '0', fosphor_glfw_sink_c_0, '0']
- [osmosdr_source_0, '0', network_udp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
